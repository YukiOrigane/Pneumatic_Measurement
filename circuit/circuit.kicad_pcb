# Repository YukiOrigane/Pneumatic_Measurement

## KiCad design circuit/circuit.kicad_pcb

Parts:
A1: Spresense; Arduino_UNO_R3
C1: 35V220uF; CP_Radial_D8.0mm_P3.50mm
C2, C3, C4: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: 24V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: 5V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3, D6: nVALVE1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: nVALVE2; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: nVALVE3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Barrel_Jack_Switch; BarrelJack_Horizontal
J2: EVS2-500-1H6AV-C13-3; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: Valve1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4, J5, J6: PSE570-02; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J7: FSM3-L200U1CH1B1N-BH; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical
J8: Valve2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9: Valve3; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10: Valve4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J11: 24V; PinHeader_2x02_P2.54mm_Vertical
J12: 5V; PinHeader_2x02_P2.54mm_Vertical
Q1, Q2, Q3, Q5: BSS138; SOT-23
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3, R4, R5, R6, R8: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R9, R10, R11, R12: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: MCP4726; SOT-23-6
U2: MCP1792x-5002xCB; SOT-23

Connections:
+5V: C3.1, C4.2, J12.1, J12.2, R7.1, R9.1, R10.1, R11.1, R12.1, U1.3 (VDD), U2.2 (VO)
+24V: C1.1, C2.1, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J11.2, R1.1, U2.3 (VI)
FLOW_SENSE: A1.10 (A1), J7.4, R6.1
GND: A1.6 (GND), A1.7 (GND), A1.29 (GND), C1.2, C2.2, C3.2, C4.1, D1.1 (K), D2.1 (K), J1.2, J2.3, J4.3, J5.3, J6.3, J7.5, J11.3, J11.4, J12.3, J12.4, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q5.2 (S), R2.2, R3.2, R4.2, R5.2, R6.2, R8.2, U1.2 (VSS), U2.1 (GND)
unnamed: A1.14 (SCL/A5), R5.1
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R7.2
unnamed: D3.2 (A), R9.2
unnamed: D4.2 (A), R10.2
unnamed: D5.2 (A), R11.2
unnamed: D6.2 (A), R12.2
unnamed: J3.2, Q5.3 (D)
unnamed: J8.2, Q1.3 (D)
unnamed: J9.2, Q2.3 (D)
unnamed: J10.2, Q3.3 (D)
PRESSURE1_SENSE: A1.11 (A2), J4.4, R2.1
PRESSURE2_SENSE: A1.12 (A3), J5.4, R3.1
PRESSURE3_SENSE: A1.13 (SDA/A4), J6.4, R4.1
REG_INPUT: J2.4, U1.1 (VOUT)
REG_SENSE: A1.9 (A0), J2.2, R8.1
SCL: A1.32 (SCL/A5), U1.5 (SCL)
SDA: A1.31 (SDA/A4), U1.4 (SDA)
VALVE1: A1.17 (D2), D3.1 (K), Q5.1 (G)
VALVE2: A1.18 (D3), D4.1 (K), Q1.1 (G)
VALVE3: A1.19 (D4), D5.1 (K), Q2.1 (G)
VALVE4: A1.20 (D5), D6.1 (K), Q3.1 (G)

Notes on the sheet:
負荷インピーダンス50kΩ以上
出力インピーダンス約1kΩ

Board: 2 copper layers, 55.0 x 55.0 mm, 41 parts (1 on the bottom side), 26 nets.

## Commit log

2025-12-01 add circuit files
2025-12-01 add ino files
2025-12-02 write spresense code
2025-12-09 add test files
2025-12-10 EVS2 test done
2026-04-09 add hys
